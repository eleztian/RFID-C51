# Keil uVision project TEST522.uvproj, settings and files
target 射频读写卡器 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: TEST522 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 主程序
    ./: bsp_sd.c main.c bsp_rc522.c bsp_rc522.h
